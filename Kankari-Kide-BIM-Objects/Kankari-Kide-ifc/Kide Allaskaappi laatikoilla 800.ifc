Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2024-08-26T13:08:35
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 22.0.2.392 - Exporter 22.0.2.392 - Alternate UI 22.0.2.392
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Aug 26 13:08:35 2024 * Host: Fazi * Database: C:\Users\INTERI~1\AppData\Local\Temp\0ce8c9f8-15da-47a3-844b-a844ad4c1d02\0e373516-6059-4cd8-81d3-e7dcfba01453\ifc * Database version: 5507 * Database creation date: Mon Aug 26 13:08:34 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Aug 26 13:08:34 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Aug 26 13:08:34 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcFurnishingElement: Kide Allaskaappi laatikoilla:Kide Allaskaappi laatikoilla 800, Kide Allaskaappi laatikoilla:Kide Allaskaappi laatikoilla 800:354882
In: Level 1
Type - Material: Valumarmori, Valkoinen,0085 White
Type - Pset_ManufacturerTypeInformation - Manufacturer: Kankari
Type - Pset_ProductRequirements - Category: Furniture
Material: Valkoinen,0085 White, Metal material, Valumarmori
Pset_QuantityTakeOff - Reference: Kide Allaskaappi laatikoilla 800

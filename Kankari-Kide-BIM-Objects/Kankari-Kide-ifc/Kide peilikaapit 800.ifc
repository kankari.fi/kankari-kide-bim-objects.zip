Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2024-08-16T16:46:52
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 22.0.2.392 - Exporter 22.0.2.392 - Alternate UI 22.0.2.392
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Aug 16 16:46:52 2024 * Host: Fazi * Database: C:\Users\INTERI~1\AppData\Local\Temp\ec6f3e97-cfeb-4a7a-8700-f2663e804bb7\d166986f-565a-4f28-8368-329c6e44a183\ifc * Database version: 5507 * Database creation date: Fri Aug 16 16:46:52 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Aug 16 16:46:52 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Aug 16 16:46:52 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcFurnishingElement: Kide peilikaapit:Kide peilikaappi 800, Kide peilikaapit:Kide peilikaappi 800:355513
In: Level 1
Type - Material: Valkoinen, 0085 White, White
Type - Pset_FurnitureTypeCommon - Description: Leveys 500,600 ja 800
Type - Pset_ManufacturerTypeInformation - Manufacturer: Kankari
Type - Pset_ProductRequirements - Category: Furniture
Material: White, Default light, Glass shelf, Valkoinen, 0085 White, Mirror
Pset_QuantityTakeOff - Reference: Kide peilikaappi 800
